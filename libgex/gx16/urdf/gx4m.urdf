Commit message: add leaphnnd and allegrohand

File: libgex/gx16/urdf/gx4m.urdf (robot description, URDF)
Before this commit: robot gx4m, 23 links, 22 joints
Joints:
- joint joint6: origin xyz=0.0175 0.03 -0.0175 rpy=1.5708 0 1.5708 -> xyz=0.02 0.028 -0.0175 rpy=1.5708 0 1.5708
